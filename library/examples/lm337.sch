G {}
V {}
C {devices/ipin} -500 20 0 0 {name=p0 lab=IN}
C {devices/ipin} -500 40 0 0 {name=p1 lab=ADJ}
C {devices/opin} -200 20 0 0 {name=p2 lab=OUT}
