G {font file} 
V {} 
S {} 
L 3 1330 -40 1330 -10 {} 
L 3 1367.5 -40 1367.5 -30 {} 
L 3 1372.5 -40 1372.5 -30 {} 
L 3 1405 -35 1405 -5 {} 
L 3 1415 -35 1415 -5 {} 
L 3 1400 -25 1420 -25 {} 
L 3 1400 -15 1420 -15 {} 
L 3 1455 -35 1460 -30 {} 
L 3 1445 -35 1455 -35 {} 
L 3 1440 -30 1445 -35 {} 
L 3 1440 -30 1440 -25 {} 
L 3 1440 -25 1445 -20 {} 
L 3 1445 -20 1455 -20 {} 
L 3 1455 -20 1460 -15 {} 
L 3 1460 -15 1460 -10 {} 
L 3 1455 -5 1460 -10 {} 
L 3 1445 -5 1455 -5 {} 
L 3 1440 -10 1445 -5 {} 
L 3 1450 -40 1450 0 {} 
L 3 1480 -5 1500 -35 {} 
L 3 1480 -35 1485 -35 {} 
L 3 1485 -35 1485 -30 {} 
L 3 1480 -30 1485 -30 {} 
L 3 1480 -35 1480 -30 {} 
L 3 1500 -10 1500 -5 {} 
L 3 1495 -5 1500 -5 {} 
L 3 1495 -10 1495 -5 {} 
L 3 1495 -10 1500 -10 {} 
L 3 1525 0 1530 0 {} 
L 3 1520 -10 1520 -5 {} 
L 3 1520 -10 1535 -32.5 {} 
L 3 1525 -30 1540 0 {} 
L 3 1528.75 -40 1532.5 -40 {} 
L 3 1570 -40 1570 -30 {} 
L 3 1605 -30 1610 -40 {} 
L 3 1605 -30 1605 -10 {} 
L 3 1605 -10 1610 0 {} 
L 3 1650 -40 1655 -30 {} 
L 3 1655 -30 1655 -10 {} 
L 3 1650 0 1655 -10 {} 
L 3 1680 -20 1700 -20 {} 
L 3 1690 -30 1690 -10 {} 
L 3 1682.5 -12.5 1697.5 -27.5 {} 
L 3 1682.5 -27.5 1697.5 -12.5 {} 
L 3 1720 -20 1740 -20 {} 
L 3 1730 -30 1730 -10 {} 
L 3 1800 -20 1820 -20 {} 
L 3 2480 -30 2500 -20 {} 
L 3 2480 -10 2500 -20 {} 
L 3 2527.5 -2.5 2527.5 0 {} 
L 3 2527.5 -2.5 2532.5 -2.5 {} 
L 3 2532.5 -2.5 2532.5 0 {} 
L 3 2527.5 0 2532.5 0 {} 
L 3 2520 -35 2525 -40 {} 
L 3 2525 -40 2535 -40 {} 
L 3 2535 -40 2540 -35 {} 
L 3 2540 -35 2540 -30 {} 
L 3 2530 -20 2540 -30 {} 
L 3 2530 -20 2530 -10 {} 
L 3 2565 -25 2570 -25 {} 
L 3 2565 -25 2565 -15 {} 
L 3 2565 -15 2570 -15 {} 
L 3 2570 -25 2570 -15 {} 
L 3 2570 -15 2575 -15 {} 
L 3 2575 -15 2580 -20 {} 
L 3 2580 -30 2580 -20 {} 
L 3 2575 -35 2580 -30 {} 
L 3 2565 -35 2575 -35 {} 
L 3 2560 -30 2565 -35 {} 
L 3 2560 -30 2560 -5 {} 
L 3 2560 -5 2565 0 {} 
L 3 2565 0 2575 0 {} 
L 3 2575 0 2580 -5 {} 
L 3 2640 -40 2640 0 {} 
L 3 2640 -40 2655 -40 {} 
L 3 2640 -20 2653.75 -20 {} 
L 3 2640 0 2655 0 {} 
L 3 2680 -35 2680 -5 {} 
L 3 2685 -40 2695 -40 {} 
L 3 2685 0 2695 0 {} 
L 3 2720 -40 2720 0 {} 
L 3 2720 0 2728.75 0 {} 
L 3 2760 -40 2760 0 {} 
L 3 2760 -40 2780 -40 {} 
L 3 2760 0 2780 0 {} 
L 3 2800 -40 2800 0 {} 
L 3 2800 -40 2820 -40 {} 
L 3 2800 -20 2815 -20 {} 
L 3 2840 -35 2840 -5 {} 
L 3 2845 0 2855 0 {} 
L 3 2860 -15 2860 -5 {} 
L 3 2850 -15 2860 -15 {} 
L 3 2845 -40 2855 -40 {} 
L 3 2880 -40 2880 0 {} 
L 3 2880 -20 2900 -20 {} 
L 3 2900 -40 2900 0 {} 
L 3 2930 -40 2930 0 {} 
L 3 2965 -40 2975 -40 {} 
L 3 2970 -40 2970 -5 {} 
L 3 3000 -40 3000 0 {} 
L 3 3000 -20 3020 -40 {} 
L 3 3000 -20 3020 0 {} 
L 3 3040 -40 3040 0 {} 
L 3 3040 0 3060 0 {} 
L 3 3080 -40 3080 0 {} 
L 3 3080 -40 3090 -25 {} 
L 3 3090 -25 3100 -40 {} 
L 3 3100 -40 3100 0 {} 
L 3 3120 -40 3120 0 {} 
L 3 3120 -40 3140 0 {} 
L 3 3140 -40 3140 0 {} 
L 3 3160 -35 3160 -5 {} 
L 3 3165 -40 3175 -40 {} 
L 3 3180 -35 3180 -5 {} 
L 3 3165 0 3175 0 {} 
L 3 3200 -40 3200 0 {} 
L 3 3200 -40 3215 -40 {} 
L 3 3220 -35 3220 -25 {} 
L 3 3200 -20 3215 -20 {} 
L 3 3240 -35 3240 -5 {} 
L 3 3245 -40 3255 -40 {} 
L 3 3280 -40 3280 0 {} 
L 3 3280 -40 3295 -40 {} 
L 3 3300 -35 3300 -25 {} 
L 3 3280 -20 3295 -20 {} 
L 3 3290 -20 3300 0 {} 
L 3 3370 -40 3370 0 {} 
L 3 3360 -40 3380 -40 {} 
L 3 3400 -40 3400 -5 {} 
L 3 3405 0 3415 0 {} 
L 3 3420 -40 3420 -5 {} 
L 3 3440 -40 3450 0 {} 
L 3 3450 0 3460 -40 {} 
L 3 3520 0 3540 -40 {} 
L 3 3520 -40 3540 0 {} 
L 3 3560 -40 3570 -20 {} 
L 3 3570 -20 3580 -40 {} 
L 3 3570 -20 3570 0 {} 
L 3 3600 -40 3620 -40 {} 
L 3 3600 0 3620 -40 {} 
L 3 3600 0 3620 0 {} 
L 3 3645 -40 3645 0 {} 
L 3 3645 0 3655 0 {} 
L 3 3645 -40 3655 -40 {} 
L 3 3680 -40 3700 0 {} 
L 3 3725 -40 3735 -40 {} 
L 3 3735 -40 3735 0 {} 
L 3 3725 0 3735 0 {} 
L 3 3760 -30 3770 -40 {} 
L 3 3770 -40 3780 -30 {} 
L 3 3800 0 3820 0 {} 
L 3 3845 -40 3855 -30 {} 
L 3 3900 -20 3900 0 {} 
L 3 3885 0 3895 0 {} 
L 3 3880 -10 3880 -5 {} 
L 3 3885 -15 3895 -15 {} 
L 3 3885 -25 3895 -25 {} 
L 3 3920 -40 3920 0 {} 
L 3 3940 -20 3940 -5 {} 
L 3 3960 -20 3960 -5 {} 
L 3 4020 -40 4020 0 {} 
L 3 4006.25 -25 4013.75 -25 {} 
L 3 4000 -20 4000 -5 {} 
L 3 4006.25 0 4013.75 0 {} 
L 3 4040 -15 4060 -15 {} 
L 3 4045 -25 4055 -25 {} 
L 3 4045 0 4055 0 {} 
L 3 4085 -32.5 4085 0 {} 
L 3 4090 -40 4095 -40 {} 
L 3 4120 -17.5 4120 -5 {} 
L 3 4160 -40 4160 0 {} 
L 3 4180 -17.5 4180 0 {} 
L 3 4210 -25 4210 0 {} 
L 3 4208.75 -35 4208.75 -32.5 {} 
L 3 4208.75 -32.5 4211.25 -32.5 {} 
L 3 4211.25 -35 4211.25 -32.5 {} 
L 3 4208.75 -35 4211.25 -35 {} 
L 3 4248.75 -35 4248.75 -32.5 {} 
L 3 4248.75 -32.5 4251.25 -32.5 {} 
L 3 4251.25 -35 4251.25 -32.5 {} 
L 3 4248.75 -35 4251.25 -35 {} 
L 3 4250 -25 4250 10 {} 
L 3 4240 15 4245 15 {} 
L 3 4280 -40 4280 0 {} 
L 3 4280 -10 4300 -25 {} 
L 3 4280 -10 4300 0 {} 
L 3 4330 -40 4330 0 {} 
L 3 4325 -40 4330 -40 {} 
L 3 4360 -25 4360 0 {} 
L 3 4400 -25 4400 0 {} 
L 3 4405 -25 4415 -25 {} 
L 3 4420 -20 4420 0 {} 
L 3 4480 -20 4480 15 {} 
L 3 4540 -25 4540 15 {} 
L 3 4563.75 -25 4563.75 0 {} 
L 3 4606.25 -25 4613.75 -25 {} 
L 3 4600 -20 4600 -17.5 {} 
L 3 4606.25 -12.5 4613.75 -12.5 {} 
L 3 4620 -7.5 4620 -5 {} 
L 3 4606.25 0 4613.75 0 {} 
L 3 4645 -40 4645 -5 {} 
L 3 4650 0 4655 0 {} 
L 3 4680 -25 4680 -5 {} 
L 3 4720 -25 4730 0 {} 
L 3 4730 0 4740 -25 {} 
L 3 4800 0 4820 -25 {} 
L 3 4800 -25 4820 0 {} 
L 3 4840 -25 4850 0 {} 
L 3 4850 0 4860 -25 {} 
L 3 4843.75 15 4850 0 {} 
L 3 4841.25 15 4843.75 15 {} 
L 3 4880 -25 4900 -25 {} 
L 3 4880 0 4900 -25 {} 
L 3 4880 0 4900 0 {} 
L 3 4930 -40 4935 -40 {} 
L 3 4925 -35 4925 -30 {} 
L 3 4925 -10 4925 -5 {} 
L 3 4930 0 4935 0 {} 
L 3 4970 -40 4970 0 {} 
L 3 5045 -40 5047.5 -40 {} 
L 3 5047.5 -40 5052.5 -35 {} 
L 3 5052.5 -35 5055 -35 {} 
L 3 4760 -25 4765 -0 {} 
L 3 4775 0 4780 -25 {} 
L 3 4645 -30 4655 -30 {} 
L 3 4140 -17.5 4140 10 {} 
L 3 4125 15 4135 15 {} 
L 3 3260 -35 3260 -5 {} 
L 3 3245 0 3255 0 {} 
L 3 3255 -10 3260 5 {} 
L 3 4697.5 -25 4697.5 0 {} 
L 3 4685 -0 4692.5 -0 {} 
L 3 4085 -15 4095 -15 {} 
L 3 1331.25 -2.5 1331.25 -0 {} 
L 3 1328.75 -2.5 1328.75 -0 {} 
L 3 1328.75 -2.5 1331.25 -2.5 {} 
L 3 1328.75 0 1331.25 -0 {} 
L 3 2760 -20 2770 -20 {} 
L 3 3480 -40 3482.5 0 {} 
L 3 3497.5 0 3500 -40 {} 
L 3 3482.5 -0 3490 -27.5 {} 
L 3 3490 -27.5 3497.5 -0 {} 
L 3 4765 -0 4770 -17.5 {} 
L 3 4770 -17.5 4775 0 {} 
L 3 2925 -40 2935 -40 {} 
L 3 2925 -0 2935 -0 {} 
L 3 2600 0 2607.5 -40 {} 
L 3 2612.5 -40 2620 0 {} 
L 3 2607.5 -40 2612.5 -40 {} 
L 3 2602.5 -12.5 2617.5 -12.5 {} 
L 3 2737.5 -32.5 2740 -22.5 {} 
L 3 2737.5 -7.5 2740 -17.5 {} 
L 3 2740 -22.5 2740 -17.5 {} 
L 3 4058.75 -2.5 4060 -5 {} 
L 3 4055 0 4058.75 -2.5 {} 
L 3 4060 -17.5 4060 -15 {} 
L 3 4058.75 -22.5 4060 -17.5 {} 
L 3 4055 -25 4058.75 -22.5 {} 
L 3 4040 -17.5 4041.25 -22.5 {} 
L 3 4041.25 -22.5 4045 -25 {} 
L 3 4040 -5 4041.25 -2.5 {} 
L 3 4041.25 -2.5 4045 0 {} 
L 3 4040 -17.5 4040 -5 {} 
L 3 4000 -20 4001.25 -22.5 {} 
L 3 4001.25 -22.5 4006.25 -25 {} 
L 3 4006.25 -25 4013.75 -25 {} 
L 3 4013.75 -25 4018.75 -22.5 {} 
L 3 4018.75 -22.5 4020 -20 {} 
L 3 4018.75 -2.5 4020 -5 {} 
L 3 4013.75 0 4018.75 -2.5 {} 
L 3 4001.25 -2.5 4006.25 0 {} 
L 3 4000 -5 4001.25 -2.5 {} 
L 3 3960 -20 3961.25 -22.5 {} 
L 3 3961.25 -22.5 3966.25 -25 {} 
L 3 3961.25 -2.5 3966.25 0 {} 
L 3 3960 -5 3961.25 -2.5 {} 
L 3 3966.25 -25 3973.75 -25 {} 
L 3 3966.25 0 3973.75 0 {} 
L 3 3966.25 -25 3973.75 -25 {} 
L 3 3973.75 -25 3978.75 -22.5 {} 
L 3 3978.75 -22.5 3980 -20 {} 
L 3 3978.75 -2.5 3980 -5 {} 
L 3 3973.75 0 3978.75 -2.5 {} 
L 3 3881.25 -2.5 3885 0 {} 
L 3 3880 -5 3881.25 -2.5 {} 
L 3 3881.25 -12.5 3885 -15 {} 
L 3 3880 -10 3881.25 -12.5 {} 
L 3 3895 0 3898.75 -2.5 {} 
L 3 3898.75 -2.5 3900 -5 {} 
L 3 3895 -15 3898.75 -12.5 {} 
L 3 3898.75 -12.5 3900 -10 {} 
L 3 3898.75 -22.5 3900 -20 {} 
L 3 3895 -25 3898.75 -22.5 {} 
L 3 3920 -20 3921.25 -22.5 {} 
L 3 3921.25 -22.5 3926.25 -25 {} 
L 3 3921.25 -2.5 3926.25 0 {} 
L 3 3920 -5 3921.25 -2.5 {} 
L 3 3926.25 -25 3933.75 -25 {} 
L 3 3926.25 0 3933.75 0 {} 
L 3 3933.75 -25 3938.75 -22.5 {} 
L 3 3938.75 -22.5 3940 -20 {} 
L 3 3938.75 -2.5 3940 -5 {} 
L 3 3933.75 0 3938.75 -2.5 {} 
L 3 4125 -25 4135 -25 {} 
L 3 4125 0 4135 0 {} 
L 3 4138.75 -2.5 4140 -5 {} 
L 3 4135 0 4138.75 -2.5 {} 
L 3 4138.75 -22.5 4140 -17.5 {} 
L 3 4135 -25 4138.75 -22.5 {} 
L 3 4120 -17.5 4121.25 -22.5 {} 
L 3 4121.25 -22.5 4125 -25 {} 
L 3 4120 -5 4121.25 -2.5 {} 
L 3 4121.25 -2.5 4125 0 {} 
L 3 4138.75 12.5 4140 10 {} 
L 3 4135 15 4138.75 12.5 {} 
L 3 4120 10 4121.25 12.5 {} 
L 3 4121.25 12.5 4125 15 {} 
L 3 4085 -32.5 4086.25 -37.5 {} 
L 3 4086.25 -37.5 4090 -40 {} 
L 3 4165 -25 4175 -25 {} 
L 3 4178.75 -22.5 4180 -17.5 {} 
L 3 4175 -25 4178.75 -22.5 {} 
L 3 4160 -17.5 4161.25 -22.5 {} 
L 3 4161.25 -22.5 4165 -25 {} 
L 3 4446.25 -25 4453.75 -25 {} 
L 3 4440 -20 4440 -5 {} 
L 3 4446.25 0 4453.75 0 {} 
L 3 4440 -20 4441.25 -22.5 {} 
L 3 4441.25 -22.5 4446.25 -25 {} 
L 3 4446.25 -25 4453.75 -25 {} 
L 3 4453.75 -25 4458.75 -22.5 {} 
L 3 4458.75 -22.5 4460 -20 {} 
L 3 4458.75 -2.5 4460 -5 {} 
L 3 4453.75 0 4458.75 -2.5 {} 
L 3 4441.25 -2.5 4446.25 0 {} 
L 3 4440 -5 4441.25 -2.5 {} 
L 3 4460 -20 4460 -5 {} 
L 3 4486.25 -25 4493.75 -25 {} 
L 3 4486.25 0 4493.75 0 {} 
L 3 4480 -20 4481.25 -22.5 {} 
L 3 4481.25 -22.5 4486.25 -25 {} 
L 3 4486.25 -25 4493.75 -25 {} 
L 3 4493.75 -25 4498.75 -22.5 {} 
L 3 4498.75 -22.5 4500 -20 {} 
L 3 4498.75 -2.5 4500 -5 {} 
L 3 4493.75 0 4498.75 -2.5 {} 
L 3 4481.25 -2.5 4486.25 0 {} 
L 3 4480 -5 4481.25 -2.5 {} 
L 3 4500 -20 4500 -5 {} 
L 3 4526.25 -25 4533.75 -25 {} 
L 3 4526.25 0 4533.75 0 {} 
L 3 4538.75 -22.5 4540 -20 {} 
L 3 4533.75 -25 4538.75 -22.5 {} 
L 3 4526.25 -25 4533.75 -25 {} 
L 3 4521.25 -22.5 4526.25 -25 {} 
L 3 4520 -20 4521.25 -22.5 {} 
L 3 4520 -5 4521.25 -2.5 {} 
L 3 4521.25 -2.5 4526.25 0 {} 
L 3 4533.75 0 4538.75 -2.5 {} 
L 3 4538.75 -2.5 4540 -5 {} 
L 3 4520 -20 4520 -5 {} 
L 3 4568.75 -25 4573.75 -25 {} 
L 3 4577.5 -22.5 4578.75 -20 {} 
L 3 4573.75 -25 4577.5 -22.5 {} 
L 3 4565 -22.5 4568.75 -25 {} 
L 3 4563.75 -20 4565 -22.5 {} 
L 3 4618.75 -22.5 4620 -20 {} 
L 3 4613.75 -25 4618.75 -22.5 {} 
L 3 4600 -20 4601.25 -22.5 {} 
L 3 4601.25 -22.5 4606.25 -25 {} 
L 3 4600 -17.5 4601.25 -15 {} 
L 3 4601.25 -15 4606.25 -12.5 {} 
L 3 4620 -7.5 4620 -5 {} 
L 3 4618.75 -10 4620 -7.5 {} 
L 3 4613.75 -12.5 4618.75 -10 {} 
L 3 4618.75 -2.5 4620 -5 {} 
L 3 4613.75 0 4618.75 -2.5 {} 
L 3 4600 -5 4601.25 -2.5 {} 
L 3 4601.25 -2.5 4606.25 0 {} 
L 3 4646.25 -1.25 4650 -0 {} 
L 3 4645 -5 4646.25 -1.25 {} 
L 3 4681.25 -2.5 4685 0 {} 
L 3 4680 -5 4681.25 -2.5 {} 
L 3 4692.5 0 4696.25 -2.5 {} 
L 3 4696.25 -2.5 4697.5 -5 {} 
L 3 4248.75 12.5 4250 10 {} 
L 3 4245 15 4248.75 12.5 {} 
L 3 4360 -20 4362.5 -23.75 {} 
L 3 4362.5 -23.75 4365 -25 {} 
L 3 4370 -20 4372.5 -23.75 {} 
L 3 4372.5 -23.75 4375 -25 {} 
L 3 4400 -20 4402.5 -23.75 {} 
L 3 4402.5 -23.75 4405 -25 {} 
L 3 4417.5 -23.75 4420 -20 {} 
L 3 4415 -25 4417.5 -23.75 {} 
L 3 4380 -23.75 4380 -0 {} 
L 3 4370 -23.75 4370 -0 {} 
L 3 4375 -25 4378.75 -25 {} 
L 3 4365 -25 4368.75 -25 {} 
L 3 4368.75 -25 4370 -23.75 {} 
L 3 4378.75 -25 4380 -23.75 {} 
L 3 4925 -20 4926.25 -21.25 {} 
L 3 4926.25 -21.25 4927.5 -23.75 {} 
L 3 4927.5 -26.25 4927.5 -23.75 {} 
L 3 4925 -30 4927.5 -26.25 {} 
L 3 4925 -20 4926.25 -18.75 {} 
L 3 4926.25 -18.75 4927.5 -16.25 {} 
L 3 4927.5 -16.25 4927.5 -13.75 {} 
L 3 4925 -10 4927.5 -13.75 {} 
L 3 4925 -35 4926.25 -37.5 {} 
L 3 4926.25 -37.5 4930 -40 {} 
L 3 4925 -5 4926.25 -2.5 {} 
L 3 4926.25 -2.5 4930 0 {} 
L 3 5005 -40 5010 -40 {} 
L 3 5015 -35 5015 -30 {} 
L 3 5015 -10 5015 -5 {} 
L 3 5005 0 5010 0 {} 
L 3 5013.75 -21.25 5015 -20 {} 
L 3 5012.5 -23.75 5013.75 -21.25 {} 
L 3 5012.5 -26.25 5012.5 -23.75 {} 
L 3 5012.5 -26.25 5015 -30 {} 
L 3 5013.75 -18.75 5015 -20 {} 
L 3 5012.5 -16.25 5013.75 -18.75 {} 
L 3 5012.5 -16.25 5012.5 -13.75 {} 
L 3 5012.5 -13.75 5015 -10 {} 
L 3 5013.75 -37.5 5015 -35 {} 
L 3 5010 -40 5013.75 -37.5 {} 
L 3 5013.75 -2.5 5015 -5 {} 
L 3 5010 0 5013.75 -2.5 {} 
L 3 5040 -35 5041.25 -37.5 {} 
L 3 5041.25 -37.5 5045 -40 {} 
L 3 5058.75 -37.5 5060 -40 {} 
L 3 5055 -35 5058.75 -37.5 {} 
L 3 1880 0 1900 -40 {} 
L 3 1965 0 1975 0 {} 
L 3 1970 -40 1970 0 {} 
L 3 1965 -30 1970 -40 {} 
L 3 2005 -40 2015 -40 {} 
L 3 2020 -35 2020 -25 {} 
L 3 2000 -5 2000 0 {} 
L 3 2000 0 2020 0 {} 
L 3 2045 -40 2053.75 -40 {} 
L 3 2060 -35 2060 -25 {} 
L 3 2045 -20 2053.75 -20 {} 
L 3 2060 -15 2060 -5 {} 
L 3 2045 0 2053.75 0 {} 
L 3 2080 -12.5 2095 -40 {} 
L 3 2080 -12.5 2100 -12.5 {} 
L 3 2095 -40 2095 0 {} 
L 3 2120 -40 2140 -40 {} 
L 3 2120 0 2133.75 0 {} 
L 3 2180 -15 2180 -5 {} 
L 3 2200 -40 2220 -40 {} 
L 3 2210 0 2220 -40 {} 
L 3 2285 0 2292.5 0 {} 
L 3 2400 -20 2420 -30 {} 
L 3 2400 -20 2420 -10 {} 
L 3 2440 -25 2460 -25 {} 
L 3 2440 -15 2460 -15 {} 
L 3 2120 -22.5 2133.75 -22.5 {} 
L 3 2120 -40 2120 -22.5 {} 
L 3 2140 -17.5 2140 -5 {} 
L 3 2300 -35 2300 -6.25 {} 
L 3 2327.5 -35 2327.5 -30 {} 
L 3 2327.5 -35 2332.5 -35 {} 
L 3 2332.5 -35 2332.5 -30 {} 
L 3 2327.5 -30 2332.5 -30 {} 
L 3 2327.5 -10 2327.5 -5 {} 
L 3 2327.5 -10 2332.5 -10 {} 
L 3 2332.5 -10 2332.5 -5 {} 
L 3 2327.5 -5 2332.5 -5 {} 
L 3 2367.5 -35 2367.5 -30 {} 
L 3 2367.5 -35 2372.5 -35 {} 
L 3 2372.5 -35 2372.5 -30 {} 
L 3 2367.5 -30 2372.5 -30 {} 
L 3 2367.5 -10 2367.5 -5 {} 
L 3 2367.5 -10 2372.5 -10 {} 
L 3 2372.5 -10 2372.5 -5 {} 
L 3 2040 -37.5 2045 -40 {} 
L 3 2040 -2.5 2045 0 {} 
L 3 2280 -2.5 2285 0 {} 
L 3 2160 -27.5 2160 -5 {} 
L 3 2166.25 -20 2173.75 -20 {} 
L 3 2160 -27.5 2163.75 -35 {} 
L 3 2170 -38.75 2176.25 -40 {} 
L 3 2163.75 -35 2170 -38.75 {} 
L 3 2000 -35 2002.5 -38.75 {} 
L 3 2002.5 -38.75 2005 -40 {} 
L 3 2015 -40 2017.5 -38.75 {} 
L 3 2017.5 -38.75 2020 -35 {} 
L 3 2018.75 -22.5 2020 -25 {} 
L 3 2016.25 -20 2018.75 -22.5 {} 
L 3 2000 -5 2001.25 -7.5 {} 
L 3 2001.25 -7.5 2003.75 -10 {} 
L 3 2003.75 -10 2016.25 -20 {} 
L 3 2058.75 -22.5 2060 -25 {} 
L 3 2053.75 -20 2058.75 -22.5 {} 
L 3 2058.75 -17.5 2060 -15 {} 
L 3 2053.75 -20 2058.75 -17.5 {} 
L 3 2178.75 -17.5 2180 -15 {} 
L 3 2173.75 -20 2178.75 -17.5 {} 
L 3 2160 -15 2161.25 -17.5 {} 
L 3 2161.25 -17.5 2166.25 -20 {} 
L 3 2257.5 -16.25 2258.75 -13.75 {} 
L 3 2255 -18.75 2257.5 -16.25 {} 
L 3 2241.25 -13.75 2242.5 -16.25 {} 
L 3 2242.5 -16.25 2245 -18.75 {} 
L 3 2245 -18.75 2248.75 -20 {} 
L 3 2251.25 -20 2255 -18.75 {} 
L 3 2240 -6.25 2241.25 -3.75 {} 
L 3 2241.25 -3.75 2243.75 -1.25 {} 
L 3 2258.75 -3.75 2260 -6.25 {} 
L 3 2256.25 -1.25 2258.75 -3.75 {} 
L 3 2252.5 0 2256.25 -1.25 {} 
L 3 2243.75 -1.25 2247.5 0 {} 
L 3 2258.75 -13.75 2260 -6.25 {} 
L 3 2240 -6.25 2241.25 -13.75 {} 
L 3 2247.5 -0 2252.5 -0 {} 
L 3 2248.75 -20 2251.25 -20 {} 
L 3 2258.75 -36.25 2260 -33.75 {} 
L 3 2256.25 -38.75 2258.75 -36.25 {} 
L 3 2240 -33.75 2241.25 -36.25 {} 
L 3 2241.25 -36.25 2243.75 -38.75 {} 
L 3 2243.75 -38.75 2247.5 -40 {} 
L 3 2252.5 -40 2256.25 -38.75 {} 
L 3 2241.25 -26.25 2242.5 -23.75 {} 
L 3 2242.5 -23.75 2245 -21.25 {} 
L 3 2257.5 -23.75 2258.75 -26.25 {} 
L 3 2255 -21.25 2257.5 -23.75 {} 
L 3 2251.25 -20 2255 -21.25 {} 
L 3 2245 -21.25 2248.75 -20 {} 
L 3 2258.75 -26.25 2260 -33.75 {} 
L 3 2240 -33.75 2241.25 -26.25 {} 
L 3 2247.5 -40 2252.5 -40 {} 
L 3 2298.75 -3.75 2300 -6.25 {} 
L 3 2296.25 -1.25 2298.75 -3.75 {} 
L 3 2292.5 0 2296.25 -1.25 {} 
L 3 2280 -35 2281.25 -37.5 {} 
L 3 2281.25 -37.5 2285 -40 {} 
L 3 2280 -25 2281.25 -22.5 {} 
L 3 2281.25 -22.5 2285 -20 {} 
L 3 2298.75 -37.5 2300 -35 {} 
L 3 2295 -40 2298.75 -37.5 {} 
L 3 2285 -40 2295 -40 {} 
L 3 2285 -20 2297.5 -20 {} 
L 3 2297.5 -20 2300 -21.25 {} 
L 3 2280 -35 2280 -25 {} 
L 3 2176.25 -40 2177.5 -40 {} 
L 3 1940 -35 1940 -5 {} 
L 3 1920 -35 1921.25 -37.5 {} 
L 3 1921.25 -37.5 1925 -40 {} 
L 3 1938.75 -37.5 1940 -35 {} 
L 3 1935 -40 1938.75 -37.5 {} 
L 3 1925 -40 1935 -40 {} 
L 3 1938.75 -2.5 1940 -5 {} 
L 3 1935 0 1938.75 -2.5 {} 
L 3 1920 -5 1921.25 -2.5 {} 
L 3 1921.25 -2.5 1925 0 {} 
L 3 1925 0 1935 0 {} 
L 3 1920 -35 1920 -5 {} 
L 3 1920 -10 1940 -30 {} 
L 3 1853.75 -5 1855 -3.75 {} 
L 3 1853.75 0 1855 -1.25 {} 
L 3 1850 -3.75 1851.25 -5 {} 
L 3 1850 -1.25 1851.25 -0 {} 
L 3 1851.25 0 1853.75 0 {} 
L 3 1855 -3.75 1855 -1.25 {} 
L 3 1851.25 -5 1853.75 -5 {} 
L 3 1850 -3.75 1850 -1.25 {} 
L 3 2371.25 -2.5 2372.5 -5 {} 
L 3 2370 -1.25 2371.25 -2.5 {} 
L 3 2366.25 0 2370 -1.25 {} 
L 3 2362.5 0 2366.25 -0 {} 
L 3 2362.5 -0 2363.75 -1.25 {} 
L 3 2363.75 -1.25 2366.25 -2.5 {} 
L 3 2366.25 -2.5 2367.5 -5 {} 
L 3 1770 -10 1770 -5 {} 
L 3 1770 -10 1775 -10 {} 
L 3 1775 -10 1775 -5 {} 
L 3 1773.75 -2.5 1775 -5 {} 
L 3 1772.5 -1.25 1773.75 -2.5 {} 
L 3 1768.75 0 1772.5 -1.25 {} 
L 3 1765 0 1768.75 0 {} 
L 3 1765 0 1766.25 -1.25 {} 
L 3 1766.25 -1.25 1768.75 -2.5 {} 
L 3 1768.75 -2.5 1770 -5 {} 
L 3 1530 0 1535 -5 {} 
L 3 1535 -5 1540 -18.75 {} 
L 3 1521.25 -2.5 1525 0 {} 
L 3 1520 -5 1521.25 -2.5 {} 
L 3 1535 -32.5 1536.25 -35 {} 
L 3 1536.25 -37.5 1536.25 -35 {} 
L 3 1535 -38.75 1536.25 -37.5 {} 
L 3 1532.5 -40 1535 -38.75 {} 
L 3 1526.25 -38.75 1528.75 -40 {} 
L 3 1525 -36.25 1526.25 -38.75 {} 
L 3 1525 -36.25 1525 -30 {} 
L 3 2058.75 -37.5 2060 -35 {} 
L 3 2053.75 -40 2058.75 -37.5 {} 
L 3 2058.75 -2.5 2060 -5 {} 
L 3 2053.75 0 2058.75 -2.5 {} 
L 3 2138.75 -20 2140 -17.5 {} 
L 3 2133.75 -22.5 2138.75 -20 {} 
L 3 2178.75 -2.5 2180 -5 {} 
L 3 2173.75 0 2178.75 -2.5 {} 
L 3 2160 -5 2161.25 -2.5 {} 
L 3 2161.25 -2.5 2166.25 0 {} 
L 3 2166.25 -0 2173.75 0 {} 
L 3 2138.75 -2.5 2140 -5 {} 
L 3 2133.75 0 2138.75 -2.5 {} 
L 3 3325 -40 3335 -40 {} 
L 3 3320 -35 3320 -25 {} 
L 3 3325 -20 3335 -20 {} 
L 3 3340 -15 3340 -5 {} 
L 3 3325 0 3335 0 {} 
L 3 3322.5 -1.25 3325 0 {} 
L 3 3320 -5 3322.5 -1.25 {} 
L 3 3335 0 3337.5 -1.25 {} 
L 3 3337.5 -1.25 3340 -5 {} 
L 3 3337.5 -18.75 3340 -15 {} 
L 3 3335 -20 3337.5 -18.75 {} 
L 3 3322.5 -21.25 3325 -20 {} 
L 3 3320 -25 3322.5 -21.25 {} 
L 3 3322.5 -38.75 3325 -40 {} 
L 3 3320 -35 3322.5 -38.75 {} 
L 3 3335 -40 3337.5 -38.75 {} 
L 3 3337.5 -38.75 3340 -35 {} 
L 3 3402.5 -1.25 3405 0 {} 
L 3 3400 -5 3402.5 -1.25 {} 
L 3 3415 0 3417.5 -1.25 {} 
L 3 3417.5 -1.25 3420 -5 {} 
L 3 3295 -20 3297.5 -21.25 {} 
L 3 3297.5 -21.25 3300 -25 {} 
L 3 3297.5 -38.75 3300 -35 {} 
L 3 3295 -40 3297.5 -38.75 {} 
L 3 3257.5 -38.75 3260 -35 {} 
L 3 3255 -40 3257.5 -38.75 {} 
L 3 3240 -35 3242.5 -38.75 {} 
L 3 3242.5 -38.75 3245 -40 {} 
L 3 3240 -5 3242.5 -1.25 {} 
L 3 3242.5 -1.25 3245 0 {} 
L 3 3257.5 -1.25 3260 -5 {} 
L 3 3255 0 3257.5 -1.25 {} 
L 3 3215 -20 3217.5 -21.25 {} 
L 3 3217.5 -21.25 3220 -25 {} 
L 3 3217.5 -38.75 3220 -35 {} 
L 3 3215 -40 3217.5 -38.75 {} 
L 3 3177.5 -38.75 3180 -35 {} 
L 3 3175 -40 3177.5 -38.75 {} 
L 3 3160 -35 3162.5 -38.75 {} 
L 3 3162.5 -38.75 3165 -40 {} 
L 3 3160 -5 3162.5 -1.25 {} 
L 3 3162.5 -1.25 3165 0 {} 
L 3 3177.5 -1.25 3180 -5 {} 
L 3 3175 0 3177.5 -1.25 {} 
L 3 2965 0 2967.5 -1.25 {} 
L 3 2967.5 -1.25 2970 -5 {} 
L 3 2960 -1.25 2962.5 0 {} 
L 3 2957.5 -5 2960 -1.25 {} 
L 3 2962.5 0 2965 -0 {} 
L 3 2857.5 -1.25 2860 -5 {} 
L 3 2855 0 2857.5 -1.25 {} 
L 3 2840 -5 2842.5 -1.25 {} 
L 3 2842.5 -1.25 2845 0 {} 
L 3 2840 -35 2842.5 -38.75 {} 
L 3 2842.5 -38.75 2845 -40 {} 
L 3 2857.5 -38.75 2860 -35 {} 
L 3 2855 -40 2857.5 -38.75 {} 
L 3 2728.75 -0 2731.25 -1.25 {} 
L 3 2731.25 -1.25 2735 -3.75 {} 
L 3 2735 -3.75 2737.5 -7.5 {} 
L 3 2720 -40 2728.75 -40 {} 
L 3 2728.75 -40 2731.25 -38.75 {} 
L 3 2731.25 -38.75 2735 -36.25 {} 
L 3 2735 -36.25 2737.5 -32.5 {} 
L 3 2697.5 -38.75 2700 -35 {} 
L 3 2695 -40 2697.5 -38.75 {} 
L 3 2680 -35 2682.5 -38.75 {} 
L 3 2682.5 -38.75 2685 -40 {} 
L 3 2680 -5 2682.5 -1.25 {} 
L 3 2682.5 -1.25 2685 0 {} 
L 3 2697.5 -1.25 2700 -5 {} 
L 3 2695 0 2697.5 -1.25 {} 
L 3 2657.5 -38.75 2660 -35 {} 
L 3 2655 -40 2657.5 -38.75 {} 
L 3 2657.5 -1.25 2660 -5 {} 
L 3 2655 0 2657.5 -1.25 {} 
L 3 2653.75 -20 2656.25 -18.75 {} 
L 3 2653.75 -20 2656.25 -21.25 {} 
L 3 2660 -12.5 2660 -5 {} 
L 3 2658.75 -16.25 2660 -12.5 {} 
L 3 2656.25 -18.75 2658.75 -16.25 {} 
L 3 2660 -35 2660 -27.5 {} 
L 3 2658.75 -23.75 2660 -27.5 {} 
L 3 2656.25 -21.25 2658.75 -23.75 {} 
