G {}
V {}
C {ipin} -500 20 0 0 {name=p0 lab=VDD}
C {ipin} -500 40 0 0 {name=p1 lab=PILOT}
C {ipin} -500 60 0 0 {name=p2 lab=OUT}
C {opin} -200 20 0 0 {name=p3 lab=IN}
C {opin} -200 40 0 0 {name=p4 lab=INB}
C {opin} -200 60 0 0 {name=p5 lab=VSS}
