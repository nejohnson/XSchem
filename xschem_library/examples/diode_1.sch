G {} 
V {} 
S {} 
N 110 -90 110 -20 {lab=m} 
N 110 -240 110 -150 {lab=p} 
N 70 -150 70 -120 {} 
N 70 -150 110 -150 {} 
N 70 -100 70 -90 {} 
N 70 -90 110 -90 {} 
C {iopin} 110 -240 0 0 {name=p0 lab=p} 
C {iopin} 110 -20 0 0 {name=p1 lab=m} 
C {switch} 110 -120 0 0 {name=G2 TABLE="'VTH-0.1' ROFF 'VTH+0.1' RON"} 
