G {}
V {}
C {ipin} -500 20 0 0 {name=p0 lab=IN}
C {ipin} -500 40 0 0 {name=p1 lab=ADJ}
C {opin} -200 20 0 0 {name=p2 lab=OUT}
