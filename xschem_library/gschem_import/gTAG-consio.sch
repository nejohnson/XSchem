** sch_path: xschem_library/gschem_import/gTAG-consio.sch
* copyleft.sym
**.subckt gTAG-consio
CONN2 xxx xxx net1 xxx
U40 net2 xxx net2 xxx net3 net4 net3 net5
**.ends
.end
