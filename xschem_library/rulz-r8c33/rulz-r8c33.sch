** sch_path: xschem_library/rulz-r8c33/rulz-r8c33.sch
* Copyright (C) 2010 DJ Delorie (dj delorie com)
* Distributed under the terms of the GNU General Public License,
* either verion 2 or (at your choice) any later version.
**.subckt rulz-r8c33
* CONN1 ?1 RAW_5V ?1 USBDM ?1 USBDP ?1 net22 ?1 GND   usb-minib
*connector(8,1) ?1 +5V ?1 GND ?1 net4 ?1 net5 ?1 net6 ?1 net7 ?1 net8 ?1 net9 ?1 net10 ?1 net11 ?1
*+ P3.3 ?1 P3.4 ?1 P3.5 ?1 P3.7
* JP1 ?1 +5V ?1 +5V
U2 +5V MODE RESET XOUT GND XIN +5V P3.7 net4 net5 net6 net7 net8 net9 net10 net11 net12 net13 net14
+ net15 RXD TXD RTS CTS P3.5 P3.4 P3.3 net21 net20 net19 net23 net24 r8c-33c
U1 USBDM USBDP net25 net26 net27 GND 3V3OUT GND USB_5V USB_5V URX UTX MODE net28 PWREN RESET CTS
+ net29 net30 net31 RTS RXD TXD GND ft232rl
* noconn #net22
* noconn GND
LED8 +5V net32 LED
R5 net32 GND 3.3k m=1
L1 RAW_5V USB_5V 600@100 m=1
C2 USB_5V GND 4.7uF m=
C1 RAW_5V GND 10nF m=1
Q1 USB_5V net1 +5V DMP2035U m=1
C3 net1 GND 100nF m=1
R1 net1 PWREN 1k m=1
LED1 +5V net2 LED
R2 net2 URX 1k m=1
LED2 +5V net3 LED
R3 net3 UTX 1k m=1
C5 +5V GND 100nF m=1
* noconn #net28
R4 +5V P3.5 3.3k m=1
R6 +5V P3.7 3.3k m=1
C6 +5V GND 100nF m=1
C4 3V3OUT GND 100nF m=1
* noconn #net27
* noconn #net26
* noconn #net25
* noconn #net29
* noconn #net30
* noconn #net31
R7 net12 net33 1k m=1
LED3 net33 GND LED
R8 net13 net34 1k m=1
LED4 net34 GND LED
R9 net14 net35 1k m=1
LED5 net35 GND LED
R10 net15 net36 1k m=1
LED6 net36 GND LED
R15 XOUT XIN 1MEG m=1
LED7 net18 net16 net17 GND GND GND XXX
R11 net19 net18 1k m=1
R12 net20 net16 1k m=1
R13 net21 net17 1k m=1
* noconn #net23
* noconn #net24
X1 XOUT GND XIN crystal-2
**.ends
.GLOBAL GND
.GLOBAL +5V
.end
